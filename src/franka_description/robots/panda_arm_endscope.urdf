Commit message: 3

File: src/franka_description/robots/panda_arm_endscope.urdf (robot description, URDF)
Before this commit: robot panda, 10 links, 9 joints
Joints:
- joint panda_joint8: origin xyz=0 0 0.49 rpy=0 0 0 -> xyz=0 0 0.278 rpy=0 0 0
